# Keil uVision project dis.uvprojx, settings and files
target dis (6190000::V6.19::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=12000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32H743xx
  c include: ..\code\Src;..\code\Drivers\STM32H7xx_HAL_Driver\Inc;..\code\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\code\Drivers\CMSIS\Include;..\code\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../code/Src/: adc.c gpio.c main.c memorymap.c stm32h7xx_it.c usart.c tim.c adc_ex.c dma.c usart_ex.c tim_ex.c crc.c crc_ex.c
  group Drivers/STM32H7xx_HAL_Driver
    ../code/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_adc.c stm32h7xx_ll_dma.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c stm32h7xx_ll_bdma.c stm32h7xx_ll_tim.c stm32h7xx_ll_crc.c
  group Drivers/CMSIS
    ../code/Src/: system_stm32h7xx.c
  group Middlewares
    ../code/Middlewares/: dis.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4
